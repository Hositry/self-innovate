# Keil uVision project template.uvprojx, settings and files
target USB BOOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CORE;..\FWLIB\inc;.\inc;..\USER;..\SYSTEM\include;..\SYSTEM\portable\RVDS\ARM_CM3;..\USB\Config\inc;..\USB\Core\inc
  memory RVCT4: ROM 0x800c800 size 0x75000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\template.sct
  group START
    ../CORE/: startup_stm32f10x_hd.s
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ./: main.c stm32f10x_it.c
    ./src/: timer.c spi.c w25qxx.c key.c led.c
  group USB_CORE
    ../USB/Core/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/Config/src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
